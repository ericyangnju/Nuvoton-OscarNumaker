# Keil uVision project Oscar-Numaker.uvproj, settings and files
target Oscar-Numaker (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: Oscar-Numaker
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\ISD9100\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Framework\inc;..\
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_ISD9100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
    ./: startup_ISD9100.s
  group User
    ../: main.c InterruptHandler.c I2c0int.c
  group Driver
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c gpio.c pwm.c timer.c i2c.c adc.c fmc.c acmp.c biq.c bod.c capsense.c CRC.c dpwm.c i2s.c pdma.c rtc.c spi.c talarm.c wdt.c
  group OLED
    ../OLED/: LY096BG30.c
  group MPU6050
    ../MPU6050/: MPU6050.c Timer_Ctrl.c AHRSLibISD9100.lib MPU6050_api.c
  group HDC1000
    ../HDC1000/: HDC1000.c
  group GPIO
    ../GPIO/: user_gpio.c
